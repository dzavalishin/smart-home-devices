# IAR project STM485.ewp, settings and files
configuration STM485 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Include; C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM485.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_eth.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_uart.c stm32f4xx_hal_hcd.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ./: 
    C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    C:/Users/dz/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ./: 
    ../Src/: eth.c i2c.c stm32f4xx_hal_msp.c usart.c dac.c can.c gpio.c usb_otg.c main.c tim.c stm32f4xx_it.c adc.c spi.c
